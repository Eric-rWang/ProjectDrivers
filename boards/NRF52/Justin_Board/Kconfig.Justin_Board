## boards/NRF52/Justin_Board/board.yml
```yaml
board:
  name: Justin_Board
  full_name: Justin_Board
  vendor: NRF52
  socs:
    - name: nrf52805
```
